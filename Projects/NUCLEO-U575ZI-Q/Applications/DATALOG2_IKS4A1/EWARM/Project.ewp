# IAR project Project.ewp, settings and files
configuration Datalog2 - Release (ARM)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: SYS_TP_MCU_STM32U5; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; SYS_TRACE=0; SYS_DBG_ENABLE_TA4=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE=1; USE_HAL_DRIVER; STM32U575xx
  ICCARM.PreInclude: ../Core/Inc/sysconfig.h
  ICCARM.CCIncludePath2: ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/DSP/Include; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/ST/threadx/common/inc; ../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../Middlewares/ST/SensorStreaming_USBX; ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers; ../../../../../Middlewares/ST/usbx/ports/generic/inc; ../../../../../Middlewares/ST/eLooM/Inc; ..\..\..\..\..\Middlewares\ST\CircularBufferDL2; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ../../../../../Drivers/CMSIS/Include; ../Core/Inc; ../PnPL/AppModel/Inc; ../PnPL/Components/Inc; ../USBX/Target; ../USBX/App; ../mx/Inc; ../../../../eLooM_Components/SensorManager/Inc; ../../../../eLooM_Components/TagManager/Inc; ../../../../../Middlewares/ST/PnPLCompManager/Inc; ../../../../eLooM_Components/EMData/Inc; ../../../../../Drivers/BSP/Components/lis2duxs12; ../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../Drivers/BSP/Components/lps22df; ../../../../../Drivers/BSP/Components/lsm6dso16is; ../../../../../Drivers/BSP/Components/lsm6dsv16x; ../../../../../Drivers/BSP/Components/sht40ad1b; ../../../../../Drivers/BSP/Components/stts22h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_DYNAMIC_MEMORY_ALLOCATION; TX_SINGLE_MODE_NON_SECURE=1
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: DATALOG2.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Datalog2 - Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; SYS_DEBUG; SYS_TP_MCU_STM32U5; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; SYS_TRACE=0; SYS_DBG_ENABLE_TA4=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE=1; USE_HAL_DRIVER; STM32U575xx
  ICCARM.CCIncludePath2: ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/DSP/Include; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/ST/threadx/common/inc; ../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../Middlewares/ST/SensorStreaming_USBX; ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers; ../../../../../Middlewares/ST/usbx/ports/generic/inc; ../../../../../Middlewares/ST/eLooM/Inc; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ../../../../../Middlewares/ST/CircularBufferDL2; ../../../../../Drivers/CMSIS/Include; ../Core/Inc; ../PnPL/AppModel/Inc; ../PnPL/Components/Inc; ../USBX/Target; ../USBX/App; ../mx/Inc; ../../../../eLooM_Components/SensorManager/Inc; ../../../../eLooM_Components/TagManager/Inc; ../../../../../Middlewares/ST/PnPLCompManager/Inc; ../../../../eLooM_Components/EMData/Inc; ..\..\..\..\eLooM_Components\DPU\Inc; ../../../../../Drivers/BSP/Components/lis2duxs12; ../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../Drivers/BSP/Components/lps22df; ../../../../../Drivers/BSP/Components/lsm6dso16is; ../../../../../Drivers/BSP/Components/lsm6dsv16x; ../../../../../Drivers/BSP/Components/sht40ad1b; ../../../../../Drivers/BSP/Components/stts22h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  AARM.ADefines: DEBUG; USE_DYNAMIC_MEMORY_ALLOCATION; TX_SINGLE_MODE_NON_SECURE=1
  OBJCOPY.OOCOutputFile: Project.srec
  group Application/eLooM_Components/EMData/Inc/events
    ../../../../eLooM_Components/EMData/Inc/events/: DataEvent.h DataEventSrc.h DataEventSrc_vtbl.h IDataEventListener.h IDataEventListener_vtbl.h
  group Application/eLooM_Components/EMData/Inc/services
    ../../../../eLooM_Components/EMData/Inc/services/: CircularBuffer.h em_data_format.h ISourceObservable.h ISourceObservable_vtbl.h
  group Application/eLooM_Components/EMData/Src/events
    ../../../../eLooM_Components/EMData/Src/events/: DataEventSrc.c
  group Application/eLooM_Components/EMData/Src/services
    ../../../../eLooM_Components/EMData/Src/services/: CircularBuffer.c em_data_format.c
  group Application/eLooM_Components/SensorManager/Inc
    ../../../../eLooM_Components/SensorManager/Inc/: ABusIF.h I2CBusIF.h I2CBusTask.h I2CBusTask_vtbl.h IBus.h IBus_vtbl.h ISensor.h ISensor_vtbl.h ISensorLL.h ISensorLL_vtbl.h LIS2DUXS12Task.h LIS2DUXS12Task_vtbl.h LIS2MDLTask.h LIS2MDLTask_vtbl.h LPS22DFTask.h LPS22DFTask_vtbl.h LSM6DSO16ISTask.h LSM6DSO16ISTask_vtbl.h LSM6DSV16XTask.h LSM6DSV16XTask_vtbl.h SensorCommands.h SensorDef.h SensorManager.h SensorRegister.h SHT40Task.h SHT40Task_vtbl.h SMMessageParser.h SPIBusIF.h STTS22HTask.h STTS22HTask_vtbl.h
  group Application/eLooM_Components/SensorManager/Inc/drivers
    ../../../../eLooM_Components/SensorManager/Inc/drivers/: I2CMasterDriver.h I2CMasterDriver_vtbl.h
  group Application/eLooM_Components/SensorManager/Inc/services
    ../../../../eLooM_Components/SensorManager/Inc/services/: SIterator.h SQuery.h SUcfProtocol.h
  group Application/eLooM_Components/SensorManager/Src
    ../../../../eLooM_Components/SensorManager/Src/: ABusIF.c I2CBusIF.c I3CBusIF.c I2CBusTask.c LIS2DUXS12Task.c LIS2MDLTask.c LPS22DFTask.c LSM6DSO16ISTask.c LSM6DSV16XTask.c SensorManager.c SensorRegister.c SHT40Task.c SMMessageParser.c SPIBusIF.c STTS22HTask.c
  group Application/eLooM_Components/SensorManager/Src/drivers
    ../../../../eLooM_Components/SensorManager/Src/drivers/: I2CMasterDriver.c
  group Application/eLooM_Components/SensorManager/Src/services
    ../../../../eLooM_Components/SensorManager/Src/services/: SIterator.c SQuery.c SUcfProtocol.c
  group Application/eLooM_Components/TagManager/Inc
    ../../../../eLooM_Components/TagManager/Inc/: TagManager.h
  group Application/eLooM_Components/TagManager/Src
    ../../../../eLooM_Components/TagManager/Src/: TagManager.c
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/Core/Inc
    ../Core/Inc/: apperror.h applowpower.h AppPowerModeHelper.h AppPowerModeHelper_vtbl.h DatalogAppTask.h DatalogAppTask_vtbl.h ICommandParse.h ICommandParse_vtbl.h IStream.h IStream_vtbl.h PnPLCompManager_conf.h SensorManager_conf.h stm32u5xx_hal_conf.h stm32u5xx_it.h sysconfig.h sysdebug_config.h TagManager_conf.h tx_user.h UtilTask.h UtilTask_vtbl.h
  group Application/User/Core/Src
    ../Core/Src/: App.c AppPowerModeHelper.c DatalogAppTask.c exti_pin_map.c ICommandParse.c IStream.c main.c stm32u5xx_hal_msp.c stm32u5xx_it.c sysinit_mx.c tx_initialize_low_level.s UtilTask.c
  group Application/User/mx/Inc
    ../mx/Inc/: crc.h gpdma.h gpio.h i2c.h icache.h main.h memorymap.h mx.h rng.h rtc.h tim.h ucpd.h usart.h usb_otg.h
  group Application/User/mx/Src
    ../mx/Src/: crc.c gpdma.c gpio.c i2c.c icache.c memorymap.c mx.c rng.c rtc.c stm32u5xx_hal_timebase_tim.c tim.c usart.c usb_otg.c
  group Application/User/PnPL/AppModel/Inc
    ../PnPL/AppModel/Inc/: App_model.h App_model_Acquisition_Info.h App_model_Automode.h App_model_Deviceinformation.h App_model_Firmware_Info.h App_model_Lis2duxs12_Acc.h App_model_Lis2duxs12_Mlc.h App_model_Lis2mdl_Mag.h App_model_Log_Controller.h App_model_Lps22df_Press.h App_model_Lsm6dso16is_Acc.h App_model_Lsm6dso16is_Gyro.h App_model_Lsm6dso16is_Ispu.h App_model_Lsm6dsv16x_Acc.h App_model_Lsm6dsv16x_Gyro.h App_model_Lsm6dsv16x_Mlc.h App_model_Sht40_Hum.h App_model_Sht40_Temp.h App_model_Stts22h_Temp.h App_model_Tags_Info.h
  group Application/User/PnPL/AppModel/Src
    ../PnPL/AppModel/Src/: App_model.c App_model_Acquisition_Info.c App_model_Automode.c App_model_Deviceinformation.c App_model_Firmware_Info.c App_model_Lis2duxs12_Acc.c App_model_Lis2duxs12_Acc.c.bak App_model_Lis2duxs12_Mlc.c App_model_Lis2mdl_Mag.c App_model_Log_Controller.c App_model_Lps22df_Press.c App_model_Lsm6dso16is_Acc.c App_model_Lsm6dso16is_Acc.c.bak App_model_Lsm6dso16is_Gyro.c App_model_Lsm6dso16is_Gyro.c.bak App_model_Lsm6dso16is_Ispu.c App_model_Lsm6dso16is_Ispu.c.bak App_model_Lsm6dsv16x_Acc.c App_model_Lsm6dsv16x_Gyro.c App_model_Lsm6dsv16x_Mlc.c App_model_Sht40_Hum.c App_model_Sht40_Temp.c App_model_Stts22h_Temp.c App_model_Tags_Info.c
  group Application/User/PnPL/Components/Inc
    ../PnPL/Components/Inc/: Acquisition_Info_PnPL.h Automode_PnPL.h Deviceinformation_PnPL.h Firmware_Info_PnPL.h Lis2duxs12_Acc_PnPL.h Lis2duxs12_Mlc_PnPL.h Lis2mdl_Mag_PnPL.h Log_Controller_PnPL.h Lps22df_Press_PnPL.h Lsm6dso16is_Acc_PnPL.h Lsm6dso16is_Gyro_PnPL.h Lsm6dso16is_Ispu_PnPL.h Lsm6dsv16x_Acc_PnPL.h Lsm6dsv16x_Gyro_PnPL.h Lsm6dsv16x_Mlc_PnPL.h Sht40_Hum_PnPL.h Sht40_Temp_PnPL.h Stts22h_Temp_PnPL.h Tags_Info_PnPL.h
  group Application/User/PnPL/Components/Src
    ../PnPL/Components/Src/: Acquisition_Info_PnPL.c Automode_PnPL.c Deviceinformation_PnPL.c Firmware_Info_PnPL.c Lis2duxs12_Acc_PnPL.c Lis2duxs12_Mlc_PnPL.c Lis2mdl_Mag_PnPL.c Log_Controller_PnPL.c Lps22df_Press_PnPL.c Lsm6dso16is_Acc_PnPL.c Lsm6dso16is_Gyro_PnPL.c Lsm6dso16is_Ispu_PnPL.c Lsm6dsv16x_Acc_PnPL.c Lsm6dsv16x_Gyro_PnPL.c Lsm6dsv16x_Mlc_PnPL.c Sht40_Hum_PnPL.c Sht40_Temp_PnPL.c Stts22h_Temp_PnPL.c Tags_Info_PnPL.c
  group Application/User/USBX/App
    ../USBX/App/: PCDDriver.c PCDDriver.h PCDDriver_vtbl.h usbx_callbacks.c usbx_callbacks.h usbx_dctrl_class.c usbx_dctrl_class.h usbx_dctrl_class_vtbl.h ux_device_descriptors.c ux_device_descriptors.h
  group Application/User/USBX/Target
    ../USBX/Target/: ux_stm32_config.h ux_user.h
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/lis2duxs12/: lis2duxs12_reg.c lis2duxs12_reg.h
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl_reg.h
    ../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c lps22df_reg.h
    ../../../../../Drivers/BSP/Components/lsm6dso16is/: lsm6dso16is_reg.c lsm6dso16is_reg.h
    ../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x_reg.c lsm6dsv16x_reg.h
    ../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b_reg.c sht40ad1b_reg.h
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h_reg.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_mdf.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_usb.c
  group Middlewares/ST/CircularBufferDL2
    ../../../../../Middlewares/ST/CircularBufferDL2/: CircularBufferDL2.c CircularBufferDL2.h
  group Middlewares/ST/eLooM/Inc/drivers
    ../../../../../Middlewares/ST/eLooM/Inc/drivers/: EXTIPinMap.h HWDriverMap.h HwTSDriver.h HwTSDriver_vtbl.h IDriver.h IDriver_vtbl.h IIODriver.h IIODriver_vtbl.h ITSDriver.h ITSDriver_vtbl.h SwTSDriver.h SwTSDriver_vtbl.h
  group Middlewares/ST/eLooM/Inc/events
    ../../../../../Middlewares/ST/eLooM/Inc/events/: AEventSrc.h AEventSrc_vtbl.h IEvent.h IEventListener.h IEventListener_vtbl.h IEventSrc.h IEventSrc_vtbl.h IListener.h IListener_vtbl.h sysevent.h
  group Middlewares/ST/eLooM/Inc/services
    ../../../../../Middlewares/ST/eLooM/Inc/services/: AManagedTask.h AManagedTask_vtbl.h AManagedTaskEx.h AManagedTaskEx_vtbl.h ApplicationContext.h IApplicationErrorDelegate.h IApplicationErrorDelegateVtbl.h IAppPowerModeHelper.h IAppPowerModeHelper_vtbl.h IBoot.h IBootVtbl.h IErrorFirstResponder.h IErrorFirstResponderVtbl.h ManagedTaskMap.h NullErrorDelegate.h syscs.h syscs_threadx.h sysdebug.h sysdeflowpower.h SysDefPowerModeHelper.h SysDefPowerModeHelper_vtbl.h syserror.h sysinit.h syslowpower.h sysmem.h SysTimestamp.h systp.h systypes.h
  group Middlewares/ST/eLooM/Src/drivers
    ../../../../../Middlewares/ST/eLooM/Src/drivers/: HwTSDriver.c SwTSDriver.c
  group Middlewares/ST/eLooM/Src/events
    ../../../../../Middlewares/ST/eLooM/Src/events/: AEventSrc.c
  group Middlewares/ST/eLooM/Src/services
    ../../../../../Middlewares/ST/eLooM/Src/services/: AManagedTask.c AManagedTaskEx.c ApplicationContext.c NullErrorDelegate.c sysdebug.c SysDefPowerModeHelper.c syserror.c sysinit.c SysTimestamp.c
  group Middlewares/ST/PnPLCompManager/Inc
    ../../../../../Middlewares/ST/PnPLCompManager/Inc/: IPnPLComponent.h IPnPLComponent_vtbl.h PnPLCompManager.h PnPLDef.h
  group Middlewares/ST/PnPLCompManager/Src
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
  group Middlewares/ST/ThreadX/common
    ../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group Middlewares/ST/ThreadX/ports
    ../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Middlewares/ST/usbx/common/core/inc
    ../../../../../Middlewares/ST/usbx/common/core/inc/: ux_api.h ux_class_audio10.h ux_class_audio20.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_hcd_sim_host.h ux_host_class_dpump.h ux_host_stack.h ux_system.h ux_user_sample.h ux_utility.h
  group Middlewares/ST/usbx/common/core/src
    ../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_read_run.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_class_dpump_write_run.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_tasks_run.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_transfer_run.c ux_device_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_tasks_run.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/ST/usbx/common/usbx_stm32_device_controllers
    ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32.h ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/ST/usbx/SensorStreaming_USBX
    ../../../../../Middlewares/ST/SensorStreaming_USBX/: ux_device_class_sensor_streaming.h ux_device_class_sensor_streaming_activate.c ux_device_class_sensor_streaming_api.c ux_device_class_sensor_streaming_bulkin_thread.c ux_device_class_sensor_streaming_control_request.c ux_device_class_sensor_streaming_deactivate.c ux_device_class_sensor_streaming_entry.c ux_device_class_sensor_streaming_initialize.c ux_device_class_sensor_streaming_read.c ux_device_class_sensor_streaming_sof.c ux_device_class_sensor_streaming_thread.c ux_device_class_sensor_streaming_write.c
  group Middlewares/Third_Party
    ../../../../../Middlewares/Third_Party/parson/: parson.c parson.h
