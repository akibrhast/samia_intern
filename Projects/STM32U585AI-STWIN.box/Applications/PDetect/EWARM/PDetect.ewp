# IAR project PDetect.ewp, settings and files
configuration PDetect - Release (ARM)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: SYS_TP_MCU_STM32U5; USE_FULL_ASSERT; SYS_TRACE=0; SYS_DBG_ENABLE_TA4=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE=1; USE_HAL_DRIVER; STM32U585xx
  ICCARM.PreInclude: ../Core/Inc/sysconfig.h
  ICCARM.CCIncludePath2: ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/DSP/Include; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../Middlewares/ST/filex/common/inc; ../../../../../Middlewares/ST/filex/ports/generic/inc; ../../../../../Middlewares/ST/threadx/common/inc; ../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../Middlewares/ST/SensorStreaming_USBX; ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers; ../../../../../Middlewares/ST/usbx/ports/generic/inc; ../../../../../Middlewares/ST/eLooM/Inc; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/hts221; ../../../../../Drivers/BSP/Components/iis2dlpc; ../../../../../Drivers/BSP/Components/iis2iclx; ../../../../../Drivers/BSP/Components/iis2mdc; ../../../../../Drivers/BSP/Components/iis3dwb; ../../../../../Drivers/BSP/Components/ilps22qs; ../../../../../Drivers/BSP/Components/ism330dhcx; ../../../../../Drivers/BSP/Components/ism330is; ../../../../../Drivers/BSP/Components/lps22hh; ../../../../../Drivers/BSP/Components/stts22h; ../../../../../Drivers/BSP/Components/sgp40; ../../../../../Drivers/BSP/Components/sht40ad1b; ../../../../../Drivers/BSP/Components/lps22df; ../../../../../Drivers/BSP/STWIN.box; ../Core/Inc; ../PnPL/AppModel/Inc; ../PnPL/Components/Inc; ../FileX/Target; ../FileX/App; ../USBX/Target; ../USBX/App; ../mx/Inc; ../../../../eLooM_Components/SensorManager/Inc; ../../../../eLooM_Components/TagManager/Inc; ../../../../../Middlewares/ST/PnPLCompManager/Inc; ../../../../eLooM_Components/EMData/Inc; ../../../../../Middlewares/ST/CircularBufferDL2; ..\..\..\..\..\Middlewares\ST\STM32_InfraredPD_Library\Inc; ..\..\..\..\..\Drivers\BSP\Components\sths34pf80; ..\..\..\..\..\Drivers\BSP\Components\vd6283tx; ..\..\..\..\..\Drivers\BSP\Components\vd6283tx\modules; ..\..\..\..\..\Drivers\BSP\Components\vl53l8cx; ..\..\..\..\..\Drivers\BSP\Components\vl53l8cx\modules; ..\..\..\..\eLooM_Components\SensorManager\Inc\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: USE_DYNAMIC_MEMORY_ALLOCATION; TX_SINGLE_MODE_NON_SECURE=1
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: PDetect.bin
  ILINK.IlinkOutputFile: PDetect.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration PDetect - Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; SYS_DEBUG; SYS_TP_MCU_STM32U5; USE_FULL_ASSERT; SYS_TRACE=0; SYS_DBG_ENABLE_TA4=0; TX_INCLUDE_USER_DEFINE_FILE; UX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE=1; USE_HAL_DRIVER; STM32U585xx
  ICCARM.CCIncludePath2: ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/DSP/Include; ../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc; ../../../../../Middlewares/ST/BlueNRG-2/includes; ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic; ../../../../../Middlewares/ST/BlueNRG-2/utils; ../../../../../Middlewares/ST/filex/common/inc; ../../../../../Middlewares/ST/filex/ports/generic/inc; ../../../../../Middlewares/ST/threadx/common/inc; ../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../Middlewares/ST/SensorStreaming_USBX; ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers; ../../../../../Middlewares/ST/usbx/ports/generic/inc; ../../../../../Middlewares/ST/eLooM/Inc; ../../../../../Middlewares/ST/CircularBufferDL2; ../../../../../Middlewares/Third_Party/parson; ../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/hts221; ../../../../../Drivers/BSP/Components/iis2dlpc; ../../../../../Drivers/BSP/Components/iis2iclx; ../../../../../Drivers/BSP/Components/iis2mdc; ../../../../../Drivers/BSP/Components/iis3dwb; ../../../../../Drivers/BSP/Components/ilps22qs; ../../../../../Drivers/BSP/Components/ism330dhcx; ../../../../../Drivers/BSP/Components/ism330is; ../../../../../Drivers/BSP/Components/lps22hh; ../../../../../Drivers/BSP/Components/stts22h; ../../../../../Drivers/BSP/Components/sgp40; ../../../../../Drivers/BSP/Components/sht40ad1b; ../../../../../Drivers/BSP/Components/lps22df; ../../../../../Drivers/BSP/STWIN.box; ../Core/Inc; ../PnPL/AppModel/Inc; ../PnPL/Components/Inc; ../FileX/Target; ../FileX/App; ../USBX/Target; ../USBX/App; ../mx/Inc; ../../../../eLooM_Components/SensorManager/Inc; ../../../../eLooM_Components/TagManager/Inc; ../../../../../Middlewares/ST/PnPLCompManager/Inc; ../../../../eLooM_Components/EMData/Inc; ../../../../../Middlewares/ST/threadx/utility/execution_profile_kit; ..\..\..\..\..\Middlewares\ST\STM32_InfraredPD_Library\Inc; ..\..\..\..\..\Drivers\BSP\Components\sths34pf80; ..\..\..\..\..\Drivers\BSP\Components\vd6283tx; ..\..\..\..\..\Drivers\BSP\Components\vd6283tx\modules; ..\..\..\..\..\Drivers\BSP\Components\vl53l8cx; ..\..\..\..\..\Drivers\BSP\Components\vl53l8cx\modules; ..\..\..\..\eLooM_Components\SensorManager\Inc\drivers
  ICCARM.CCOptLevel: 0
  AARM.ADefines: DEBUG; USE_DYNAMIC_MEMORY_ALLOCATION; TX_SINGLE_MODE_NON_SECURE=1; TX_INCLUDE_USER_DEFINE_FILE
  group Application/eLooM_Components/EMData/Inc/events
    ../../../../eLooM_Components/EMData/Inc/events/: DataEvent.h DataEventSrc.h DataEventSrc_vtbl.h IDataEventListener.h IDataEventListener_vtbl.h
  group Application/eLooM_Components/EMData/Inc/services
    ../../../../eLooM_Components/EMData/Inc/services/: CircularBuffer.h em_data_format.h ISourceObservable.h ISourceObservable_vtbl.h
  group Application/eLooM_Components/EMData/Src/events
    ../../../../eLooM_Components/EMData/Src/events/: DataEventSrc.c
  group Application/eLooM_Components/EMData/Src/services
    ../../../../eLooM_Components/EMData/Src/services/: CircularBuffer.c em_data_format.c
  group Application/eLooM_Components/SensorManager/Inc
    ../../../../eLooM_Components/SensorManager/Inc/: ABusIF.h I2CBusIF.h I2CBusTask.h I2CBusTask_vtbl.h IBus.h IBus_vtbl.h IIS2DLPCTask.h IIS2DLPCTask_vtbl.h IIS2ICLXTask.h IIS2ICLXTask_vtbl.h IIS2MDCTask.h IIS2MDCTask_vtbl.h IIS3DWBTask.h IIS3DWBTask_vtbl.h ILPS22QSTask.h ILPS22QSTask_vtbl.h IMP23ABSUTask.h IMP23ABSUTask_vtbl.h IMP34DT05Task.h IMP34DT05Task_vtbl.h ISensor.h ISensor_vtbl.h ISensorMlc.h ISensorMlc_vtbl.h ISM330DHCXTask.h ISM330DHCXTask_vtbl.h ISM330ISTask.h ISM330ISTask_vtbl.h LPS22HHTask.h LPS22HHTask_vtbl.h SensorCommands.h SensorDef.h SensorManager.h SensorRegister.h SGP40Task.h SGP40Task_vtbl.h SHT40Task.h SHT40Task_vtbl.h SMMessageParser.h SPIBusIF.h SPIBusTask.h SPIBusTask_vtbl.h STTS22HTask.h STTS22HTask_vtbl.h
  group Application/eLooM_Components/SensorManager/Inc/drivers
    ../../../../eLooM_Components/SensorManager/Inc/drivers/: AnalogMicDriver.h AnalogMicDriver_vtbl.h I2CMasterDriver.h I2CMasterDriver_vtbl.h MDFDriver.h MDFDriver_vtbl.h SMUtilityDriver.h SMUtilityDriver_vtbl.h SPIMasterDriver.h SPIMasterDriver_vtbl.h
  group Application/eLooM_Components/SensorManager/Inc/services
    ../../../../eLooM_Components/SensorManager/Inc/services/: SIterator.h SQuery.h SUcfProtocol.h
  group Application/eLooM_Components/SensorManager/Src
    ../../../../eLooM_Components/SensorManager/Src/: ABusIF.c I2CBSBusIF.c I2CBusIF.c I3CBusIF.c I2CBusTask.c IIS2DLPCTask.c IIS2ICLXTask.c IIS2MDCTask.c IIS3DWBTask.c ILPS22QSTask.c IMP23ABSUTask.c IMP34DT05Task.c ISM330DHCXTask.c ISM330ISTask.c LPS22DFTask.c SensorManager.c SensorRegister.c SGP40Task.c SHT40Task.c SMMessageParser.c SPIBusIF.c SPIBusTask.c STHS34PF80Task.c STTS22HTask.c VD6283TXTask.c VL53L8CXTask.c
  group Application/eLooM_Components/SensorManager/Src/drivers
    ../../../../eLooM_Components/SensorManager/Src/drivers/: AnalogMicDriver.c I2CMasterDriver.c MDFDriver.c platform.c SPIMasterDriver.c
  group Application/eLooM_Components/SensorManager/Src/services
    ../../../../eLooM_Components/SensorManager/Src/services/: SIterator.c SQuery.c SUcfProtocol.c
  group Application/eLooM_Components/TagManager/Inc
    ../../../../eLooM_Components/TagManager/Inc/: TagManager.h
  group Application/eLooM_Components/TagManager/Src
    ../../../../eLooM_Components/TagManager/Src/: TagManager.c
  group Application/EWARM
    ./: startup_stm32u585xx.s
  group Application/User/Core/Inc
    ../Core/Inc/: app_messages_parser.h App_model.h app_threadx.h apperror.h applowpower.h AppPowerModeHelper.h AppPowerModeHelper_vtbl.h automode.h ble_implementation.h ble_list_utils.h ble_manager_conf.h ble_stream_class.h ble_stream_class_vtbl.h bluenrg_conf.h DatalogAppTask.h DatalogAppTask_vtbl.h dfu_boot.h HardwareDetection.h hci_tl_interface.h ICommandParse.h ICommandParse_vtbl.h IStream.h IStream_vtbl.h main.h OTA.h PnPLCompManager_conf.h SensorDefConfig.h SensorManager_conf.h SMPinConfig.h stm32u5xx_hal_conf.h stm32u5xx_it.h STWIN.box_conf.h sysconfig.h sysdebug_config.h tx_user.h UtilTask.h UtilTask_vtbl.h
  group Application/User/Core/Inc/drivers
    ../Core/Inc/drivers/: BCAdcDriver.h BCAdcDriver_vtbl.h BCTimChgDriver.h BCTimChgDriver_vtbl.h BCTimerDriver.h BCTimerDriver_vtbl.h
  group Application/User/Core/Inc/services
    ../Core/Inc/services/: BCProtocol.h
  group Application/User/Core/Src
    ../Core/Src/: App.c AppPowerModeHelper.c automode.c ble_implementation.c ble_stream_class.c DatalogAppTask.c dfu_boot.c exti_pin_map.c HardwareDetection.c hci_tl_interface.c ICommandParse.c IStream.c main.c OTA.c stm32u5xx_it.c sysinit_mx.c task_execution_profile.c tx_initialize_low_level.s UtilTask.c
  group Application/User/Core/Src/drivers
    ../Core/Src/drivers/: BCAdcDriver.c BCTimChgDriver.c BCTimerDriver.c
  group Application/User/Core/Src/services
    ../Core/Src/services/: BCProtocol.c
  group Application/User/FileX/App
    ../FileX/App/: filex_dctrl_class.c filex_dctrl_class.h filex_dctrl_class_vtbl.h fx_user.h
  group Application/User/FileX/Target
    ../FileX/Target/: fx_stm32_sd_driver.h fx_stm32_sd_driver_glue.c
  group Application/User/mx/Inc
    ../mx/Inc/: adc.h dac.h gpdma.h gpio.h i2c.h icache.h main.h mdf.h rng.h rtc.h sdmmc.h spi.h tim.h usart.h usb_otg.h
  group Application/User/mx/Src
    ../mx/Src/: adc.c crc.c dac.c gpdma.c gpio.c i2c.c icache.c lptim.c mdf.c mx.c rng.c rtc.c sdmmc.c spi.c stm32u5xx_hal_timebase_tim.c tim.c usart.c usb_otg.c
  group Application/User/PnPL/AppModel/Inc
    ../PnPL/AppModel/Inc/: App_model.h App_model_Acquisition_Info.h App_model_Automode.h App_model_Deviceinformation.h App_model_Firmware_Info.h App_model_Iis2iclx_Acc.h App_model_Iis2mdc_Mag.h App_model_Ilps22qs_Press.h App_model_Imp34dt05_Mic.h App_model_Ism330dhcx_Acc.h App_model_Ism330dhcx_Gyro.h App_model_Log_Controller.h App_model_Lps22df_Press.h App_model_Sgp40_Voc.h App_model_Sht40_Hum.h App_model_Sht40_Temp.h App_model_Sths34pf80_2_Tmos.h App_model_Sths34pf80_3_Tmos.h App_model_Sths34pf80_Tmos.h App_model_Stts22h_Temp.h App_model_Tags_Info.h App_model_Vd6283tx_2_Als.h App_model_Vd6283tx_3_Als.h App_model_Vd6283tx_Als.h App_model_Vl53l8cx_2_Tof.h App_model_Vl53l8cx_3_Tof.h App_model_Vl53l8cx_Tof.h
  group Application/User/PnPL/AppModel/Src
    ../PnPL/AppModel/Src/: App_model.c App_model_Acquisition_Info.c App_model_Automode.c App_model_Deviceinformation.c App_model_Firmware_Info.c App_model_Iis2iclx_Acc.c App_model_Iis2mdc_Mag.c App_model_Ilps22qs_Press.c App_model_Imp34dt05_Mic.c App_model_Ism330dhcx_Acc.c App_model_Ism330dhcx_Gyro.c App_model_Log_Controller.c App_model_Lps22df_Press.c App_model_Sgp40_Voc.c App_model_Sht40_Hum.c App_model_Sht40_Temp.c App_model_Sths34pf80_2_Tmos.c App_model_Sths34pf80_3_Tmos.c App_model_Sths34pf80_Tmos.c App_model_Stts22h_Temp.c App_model_Tags_Info.c App_model_Vd6283tx_2_Als.c App_model_Vd6283tx_3_Als.c App_model_Vd6283tx_Als.c App_model_Vl53l8cx_2_Tof.c App_model_Vl53l8cx_3_Tof.c App_model_Vl53l8cx_Tof.c
  group Application/User/PnPL/Components/Inc
    ../PnPL/Components/Inc/: Acquisition_Info_PnPL.h Automode_PnPL.h Deviceinformation_PnPL.h Firmware_Info_PnPL.h Iis2iclx_Acc_PnPL.h Iis2mdc_Mag_PnPL.h Ilps22qs_Press_PnPL.h Imp34dt05_Mic_PnPL.h Ism330dhcx_Acc_PnPL.h Ism330dhcx_Gyro_PnPL.h Log_Controller_PnPL.h Lps22df_Press_PnPL.h Sgp40_Voc_PnPL.h Sht40_Hum_PnPL.h Sht40_Temp_PnPL.h Sths34pf80_2_Tmos_PnPL.h Sths34pf80_3_Tmos_PnPL.h Sths34pf80_Tmos_PnPL.h Stts22h_Temp_PnPL.h Tags_Info_PnPL.h Vd6283tx_2_Als_PnPL.h Vd6283tx_3_Als_PnPL.h Vd6283tx_Als_PnPL.h Vl53l8cx_2_Tof_PnPL.h Vl53l8cx_3_Tof_PnPL.h Vl53l8cx_Tof_PnPL.h
  group Application/User/PnPL/Components/Src
    ../PnPL/Components/Src/: Acquisition_Info_PnPL.c Automode_PnPL.c Deviceinformation_PnPL.c Firmware_Info_PnPL.c Iis2iclx_Acc_PnPL.c Iis2mdc_Mag_PnPL.c Ilps22qs_Press_PnPL.c Imp34dt05_Mic_PnPL.c Ism330dhcx_Acc_PnPL.c Ism330dhcx_Gyro_PnPL.c Log_Controller_PnPL.c Lps22df_Press_PnPL.c Sgp40_Voc_PnPL.c Sht40_Hum_PnPL.c Sht40_Temp_PnPL.c Sths34pf80_2_Tmos_PnPL.c Sths34pf80_3_Tmos_PnPL.c Sths34pf80_Tmos_PnPL.c Stts22h_Temp_PnPL.c Tags_Info_PnPL.c Vd6283tx_2_Als_PnPL.c Vd6283tx_3_Als_PnPL.c Vd6283tx_Als_PnPL.c Vl53l8cx_2_Tof_PnPL.c Vl53l8cx_3_Tof_PnPL.c Vl53l8cx_Tof_PnPL.c
  group Application/User/USBX/App
    ../USBX/App/: PCDDriver.c PCDDriver.h PCDDriver_vtbl.h usbx_callbacks.c usbx_callbacks.h usbx_dctrl_class.c usbx_dctrl_class.h usbx_dctrl_class_vtbl.h ux_device_descriptors.c ux_device_descriptors.h ux_user.h
  group Application/User/USBX/Target
    ../USBX/Target/: ux_stm32_config.h
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc_reg.c
    ../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx_reg.c
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c
    ../../../../../Drivers/BSP/Components/iis3dwb/: iis3dwb_reg.c
    ../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs_reg.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/ism330is/: ism330is_reg.c
    ../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/sgp40/: sgp40.c sgp40_reg.c
    ../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b.c sht40ad1b_reg.c
    ../../../../../Drivers/BSP/Components/sths34pf80/: sths34pf80.c sths34pf80_reg.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c
    ../../../../../Drivers/BSP/Components/vd6283tx/modules/: VD6283.c
    ../../../../../Drivers/BSP/Components/vd6283tx/: vd6283tx.c
    ../../../../../Drivers/BSP/Components/vl53l8cx/modules/: vl53l8cx_api.c vl53l8cx_plugin_detection_thresholds.c vl53l8cx_plugin_motion_indicator.c vl53l8cx_plugin_xtalk.c
  group Drivers/BSP/STWIN.box
    ../../../../../Drivers/BSP/STWIN.box/: STWIN.box_debug_pins.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_mdf.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Middlewares/ST/BlueNRG-2/hci
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_dev_config.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/ST/BlueNRG-2/hci/controller
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c hci_tl.h
  group Middlewares/ST/BlueNRG-2/includes
    ../../../../../Middlewares/ST/BlueNRG-2/includes/: ble_const.h ble_status.h ble_types.h bluenrg1_aci.h bluenrg1_events.h bluenrg1_gap.h bluenrg1_gap_aci.h bluenrg1_gatt_aci.h bluenrg1_gatt_server.h bluenrg1_hal.h bluenrg1_hal_aci.h bluenrg1_hci_le.h bluenrg1_l2cap_aci.h bluenrg1_types.h bluenrg_conf_template.h bluenrg_utils.h compiler.h hci.h hci_const.h link_layer.h sm.h
  group Middlewares/ST/BlueNRG-2/utils
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c ble_list.h
  group Middlewares/ST/CircularBufferDL2
    ../../../../../Middlewares/ST/CircularBufferDL2/: CircularBufferDL2.c CircularBufferDL2.h
  group Middlewares/ST/eLooM/Inc/drivers
    ../../../../../Middlewares/ST/eLooM/Inc/drivers/: EXTIPinMap.h HwTSDriver.h HwTSDriver_vtbl.h IDriver.h IDriver_vtbl.h IIODriver.h IIODriver_vtbl.h ITSDriver.h ITSDriver_vtbl.h SwTSDriver.h SwTSDriver_vtbl.h
  group Middlewares/ST/eLooM/Inc/events
    ../../../../../Middlewares/ST/eLooM/Inc/events/: AEventSrc.h AEventSrc_vtbl.h IEvent.h IEventListener.h IEventListener_vtbl.h IEventSrc.h IEventSrc_vtbl.h IListener.h IListener_vtbl.h ISourceObservable.h ISourceObservable_vtbl.h sysevent.h
  group Middlewares/ST/eLooM/Inc/services
    ../../../../../Middlewares/ST/eLooM/Inc/services/: AManagedTask.h AManagedTask_vtbl.h AManagedTaskEx.h AManagedTaskEx_vtbl.h ApplicationContext.h IApplicationErrorDelegate.h IApplicationErrorDelegateVtbl.h IAppPowerModeHelper.h IAppPowerModeHelper_vtbl.h IBoot.h IBootVtbl.h IErrorFirstResponder.h IErrorFirstResponderVtbl.h ManagedTaskMap.h NullErrorDelegate.h sysdebug.h sysdeflowpower.h SysDefPowerModeHelper.h SysDefPowerModeHelper_vtbl.h syserror.h sysinit.h syslowpower.h sysmem.h SysTimestamp.h systp.h systypes.h
  group Middlewares/ST/eLooM/Src/drivers
    ../../../../../Middlewares/ST/eLooM/Src/drivers/: HwTSDriver.c SwTSDriver.c
  group Middlewares/ST/eLooM/Src/events
    ../../../../../Middlewares/ST/eLooM/Src/events/: AEventSrc.c
  group Middlewares/ST/eLooM/Src/services
    ../../../../../Middlewares/ST/eLooM/Src/services/: AManagedTask.c AManagedTaskEx.c ApplicationContext.c NullErrorDelegate.c sysdebug.c SysDefPowerModeHelper.c syserror.c sysinit.c SysTimestamp.c
  group Middlewares/ST/FileX/common/drivers
    ../../../../../Middlewares/ST/filex/common/drivers/: fx_stm32_sd_driver.c
  group Middlewares/ST/FileX/common/inc
    ../../../../../Middlewares/ST/filex/common/inc/: fx_api.h fx_directory.h fx_directory_exFAT.h fx_fault_tolerant.h fx_file.h fx_media.h fx_system.h fx_unicode.h fx_user_sample.h fx_utility.h
  group Middlewares/ST/FileX/common/src
    ../../../../../Middlewares/ST/filex/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get.c fx_directory_default_get_copy.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get.c fx_directory_local_path_get_copy.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get.c fx_directory_long_name_get_extended.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get.c fx_directory_short_name_get_extended.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate.c fx_file_extended_truncate_release.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate.c fx_file_truncate_release.c fx_file_write.c fx_file_write_notify_set.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_close.c fx_media_close_notify_set.c fx_media_exFAT_format.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_open.c fx_media_open_notify_set.c fx_media_read.c fx_media_space_available.c fx_media_volume_get.c fx_media_volume_get_extended.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_ram_driver.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_absolute_path_get.c fx_utility_exFAT_allocate_new_cluster.c fx_utility_exFAT_bitmap_cache_prepare.c fx_utility_exFAT_bitmap_cache_update.c fx_utility_exFAT_bitmap_flush.c fx_utility_exFAT_bitmap_free_cluster_find.c fx_utility_exFAT_bitmap_initialize.c fx_utility_exFAT_bitmap_start_sector_get.c fx_utility_exFAT_cluster_free.c fx_utility_exFAT_cluster_state_get.c fx_utility_exFAT_cluster_state_set.c fx_utility_exFAT_geometry_check.c fx_utility_exFAT_name_hash_get.c fx_utility_exFAT_size_calculate.c fx_utility_exFAT_system_area_checksum_verify.c fx_utility_exFAT_system_area_checksum_write.c fx_utility_exFAT_system_area_format.c fx_utility_exFAT_system_sector_write.c fx_utility_exFAT_unicode_name_hash_get.c fx_utility_exFAT_upcase_table.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c fxe_directory_attributes_read.c fxe_directory_attributes_set.c fxe_directory_create.c fxe_directory_default_get.c fxe_directory_default_get_copy.c fxe_directory_default_set.c fxe_directory_delete.c fxe_directory_first_entry_find.c fxe_directory_first_full_entry_find.c fxe_directory_information_get.c fxe_directory_local_path_clear.c fxe_directory_local_path_get.c fxe_directory_local_path_get_copy.c fxe_directory_local_path_restore.c fxe_directory_local_path_set.c fxe_directory_long_name_get.c fxe_directory_long_name_get_extended.c fxe_directory_name_test.c fxe_directory_next_entry_find.c fxe_directory_next_full_entry_find.c fxe_directory_rename.c fxe_directory_short_name_get.c fxe_directory_short_name_get_extended.c fxe_fault_tolerant_enable.c fxe_file_allocate.c fxe_file_attributes_read.c fxe_file_attributes_set.c fxe_file_best_effort_allocate.c fxe_file_close.c fxe_file_create.c fxe_file_date_time_set.c fxe_file_delete.c fxe_file_extended_allocate.c fxe_file_extended_best_effort_allocate.c fxe_file_extended_relative_seek.c fxe_file_extended_seek.c fxe_file_extended_truncate.c fxe_file_extended_truncate_release.c fxe_file_open.c fxe_file_read.c fxe_file_relative_seek.c fxe_file_rename.c fxe_file_seek.c fxe_file_truncate.c fxe_file_truncate_release.c fxe_file_write.c fxe_file_write_notify_set.c fxe_media_abort.c fxe_media_cache_invalidate.c fxe_media_check.c fxe_media_close.c fxe_media_close_notify_set.c fxe_media_exFAT_format.c fxe_media_extended_space_available.c fxe_media_flush.c fxe_media_format.c fxe_media_open.c fxe_media_open_notify_set.c fxe_media_read.c fxe_media_space_available.c fxe_media_volume_get.c fxe_media_volume_get_extended.c fxe_media_volume_set.c fxe_media_write.c fxe_system_date_get.c fxe_system_date_set.c fxe_system_time_get.c fxe_system_time_set.c
  group Middlewares/ST/FileX/ports
    ../../../../../Middlewares/ST/filex/ports/generic/inc/: fx_port.h
  group Middlewares/ST/PnPLCompManager/Inc
    ../../../../../Middlewares/ST/PnPLCompManager/Inc/: IPnPLComponent.h IPnPLComponent_vtbl.h PnPLCompManager.h PnPLDef.h
  group Middlewares/ST/PnPLCompManager/Src
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
  group Middlewares/ST/STM32_BLE_Manager/Inc
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Inc/: ble_machine_learning_core.h ble_manager.h ble_manager_common.h ble_manager_control.h ble_pn_p_like.h
  group Middlewares/ST/STM32_BLE_Manager/Src
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_high_speed_data_log.c ble_machine_learning_core.c ble_manager.c ble_pn_p_like.c
  group Middlewares/ST/STM32_InfraredPD_Library
    ../../../../../Middlewares/ST/STM32_InfraredPD_Library/Lib/: InfraredPD_CM33F_wc32_ot_hard.a
  group Middlewares/ST/ThreadX/common
    ../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
  group Middlewares/ST/ThreadX/ports
    ../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Middlewares/ST/usbx/common/core/inc
    ../../../../../Middlewares/ST/usbx/common/core/inc/: ux_api.h ux_dcd_sim_slave.h ux_device_class_dpump.h ux_device_stack.h ux_hcd_sim_host.h ux_host_class_dpump.h ux_host_stack.h ux_system.h ux_user_sample.h ux_utility.h
  group Middlewares/ST/usbx/common/core/src
    ../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c ux_trace_event_insert.c ux_trace_event_update.c ux_trace_object_register.c ux_trace_object_unregister.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/ST/usbx/common/usbx_stm32_device_controllers
    ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32.h ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c
  group Middlewares/ST/usbx/SensorStreaming_USBX
    ../../../../../Middlewares/ST/SensorStreaming_USBX/: ux_device_class_sensor_streaming.h ux_device_class_sensor_streaming_activate.c ux_device_class_sensor_streaming_api.c ux_device_class_sensor_streaming_bulkin_thread.c ux_device_class_sensor_streaming_control_request.c ux_device_class_sensor_streaming_deactivate.c ux_device_class_sensor_streaming_entry.c ux_device_class_sensor_streaming_initialize.c ux_device_class_sensor_streaming_read.c ux_device_class_sensor_streaming_sof.c ux_device_class_sensor_streaming_thread.c ux_device_class_sensor_streaming_write.c
  group Middlewares/Third_Party/parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
