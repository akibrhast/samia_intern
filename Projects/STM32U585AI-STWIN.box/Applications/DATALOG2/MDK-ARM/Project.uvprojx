# Keil uVision project Project.uvprojx, settings and files
target Datalog2_Debug (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Datalog2_Debug +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG, SYS_DEBUG, SYS_TP_MCU_STM32U5, USE_FULL_ASSERT, SYS_TRACE=0, SYS_DBG_ENABLE_TA4=0, NX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, UX_INCLUDE_USER_DEFINE_FILE, USE_HAL_DRIVER, STM32U585xx
  c misc: --include=sysconfig.h
  c include: ../Core/Inc;../FileX/Target;../FileX/App;../USBX/Target;../USBX/App;../mx/Inc;..\PnPL\AppModel\Inc;..\PnPL\Components\Inc;../../../../eLooM_Components/SensorManager/Inc;../../../../eLooM_Components/TagManager/Inc;..\..\..\..\..\Middlewares\ST\PnPLCompManager\Inc;..\..\..\..\eLooM_Components\EMData\Inc;../../../../../Middlewares/ST/STM32_BLE_Manager/Inc;../../../../../Middlewares/ST/BlueNRG-2/includes;../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG-2/utils;../../../../../Middlewares/ST/filex/common/inc;../../../../../Middlewares/ST/filex/ports/generic/inc;../../../../../Middlewares/ST/threadx/common/inc;../../../../../Middlewares/ST/usbx/common/core/inc;../../../../../Middlewares/ST/SensorStreaming_USBX;../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../../../../../Middlewares/ST/usbx/ports/generic/inc;..\..\..\..\..\Middlewares\ST\CircularBufferDL2;../../../../../Middlewares/ST/eLooM/Inc;../../../../../Middlewares/Third_Party/parson;../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../../../../../Drivers/STM32U5xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/iis2dlpc;..\..\..\..\..\Drivers\BSP\Components\iis2dulpx;../../../../../Drivers/BSP/Components/iis2iclx;../../../../../Drivers/BSP/Components/iis2mdc;../../../../../Drivers/BSP/Components/iis3dwb;../../../../../Drivers/BSP/Components/ilps22qs;..\..\..\..\..\Drivers\BSP\Components\ism330bx;../../../../../Drivers/BSP/Components/ism330is;../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/stts22h;../../../../../Drivers/BSP/STWIN.box;..\..\..\..\..\Middlewares\ST\netxduo\addons\dhcp;..\..\..\..\..\Middlewares\ST\netxduo\addons\dns;..\..\..\..\..\Middlewares\ST\netxduo\addons\ftp;..\..\..\..\..\Middlewares\ST\netxduo\addons\sntp;..\..\..\..\..\Drivers\BSP\Components\mx_wifi;..\..\..\..\..\Drivers\BSP\Components\mx_wifi\core;..\..\..\..\..\Drivers\BSP\Components\mx_wifi\io_pattern;..\NetX\app;..\..\..\..\..\Middlewares\ST\netxduo\ports\cortex_m33\gnu\inc;..\..\..\..\..\Middlewares\ST\netxduo\common\inc;..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\wifi\mxchip;..\..\..\..\..\Drivers\BSP\Components\ilps28qsw;..\..\..\..\..\Drivers\BSP\Components\ism6hg256x;..\..\..\..\..\Drivers\BSP\Components\iis3dwb10is
  asm define: DEBUG, USE_DYNAMIC_MEMORY_ALLOCATION, TX_SINGLE_MODE_NON_SECURE=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/Core
    ../Core/Src/: App.c AppPowerModeHelper.c automode.c ble_implementation.c ble_stream_class.c DatalogAppTask.c exti_pin_map.c HardwareDetection.c hci_tl_interface.c ICommandParse.c IStream.c main.c OTA.c stm32u5xx_it.c syscalls.c sysinit_mx.c task_execution_profile.c UtilTask.c tx_initialize_low_level.s IWifi_Config.c TSC1641.c dfu_boot.c
    ../Core/Src/drivers/: BCAdcDriver.c BCTimChgDriver.c BCTimerDriver.c
    ../Core/Src/services/: BCProtocol.c
  group Application/FileX
    ../FileX/App/: filex_dctrl_class.c
    ../FileX/Target/: fx_stm32_sd_driver_glue.c
  group Application/mx
    ../mx/Src/: adc.c dac.c gpdma.c gpio.c i2c.c icache.c mdf.c mx.c sai.c spi.c stm32u5xx_hal_timebase_tim.c tim.c usart.c usb_otg.c rng.c rtc.c sdmmc.c lptim.c
  group Application/NetX
    ../NetX/app/: app_netxduo.c
    ../NetX/patch/: mx_wifi_azure_rtos_patched.c nxd_ftp_server_patched.c
  group Application/PnPL/AppModel
    ../PnPL/AppModel/Src/: App_model.c App_model_Acquisition_Info.c App_model_Automode.c App_model_Deviceinformation.c App_model_Firmware_Info.c App_model_Iis2dlpc_Acc.c App_model_Iis2iclx_Acc.c App_model_Iis2mdc_Mag.c App_model_Iis3dwb_Acc.c App_model_Iis3dwb_Ext_Acc.c App_model_Ilps22qs_Press.c App_model_Imp23absu_Mic.c App_model_Imp34dt05_Mic.c App_model_Ism330bx_Acc.c App_model_Ism330bx_Gyro.c App_model_Ism330bx_Mlc.c App_model_Ism330dhcx_Acc.c App_model_Ism330dhcx_Gyro.c App_model_Ism330dhcx_Mlc.c App_model_Ism330is_Acc.c App_model_Ism330is_Gyro.c App_model_Ism330is_Ispu.c App_model_Log_Controller.c App_model_Stts22h_Ext_Temp.c App_model_Stts22h_Temp.c App_model_Tags_Info.c App_model_Tsc1641_Pow.c App_model_Wifi_Config.c App_model_Iis2dulpx_Acc.c App_model_Iis2dulpx_Mlc.c App_model_Iis2iclx_Mlc.c App_model_Iis3dwb10is_Acc.c App_model_Ilps28qsw_Press.c App_model_Ism6hg256x_Gyro.c App_model_Ism6hg256x_H_Acc.c App_model_Ism6hg256x_L_Acc.c App_model_Ism6hg256x_Mlc.c App_model_Iis3dwb10is_Ispu.c
  group Application/PnPL/Components
    ../PnPL/Components/Src/: Acquisition_Info_PnPL.c Automode_PnPL.c Deviceinformation_PnPL.c Firmware_Info_PnPL.c Iis2dlpc_Acc_PnPL.c Iis2iclx_Acc_PnPL.c Iis2mdc_Mag_PnPL.c Iis3dwb_Acc_PnPL.c Iis3dwb_Ext_Acc_PnPL.c Ilps22qs_Press_PnPL.c Imp23absu_Mic_PnPL.c Imp34dt05_Mic_PnPL.c Ism330bx_Acc_PnPL.c Ism330bx_Gyro_PnPL.c Ism330bx_Mlc_PnPL.c Ism330dhcx_Acc_PnPL.c Ism330dhcx_Gyro_PnPL.c Ism330dhcx_Mlc_PnPL.c Ism330is_Acc_PnPL.c Ism330is_Gyro_PnPL.c Ism330is_Ispu_PnPL.c Log_Controller_PnPL.c Stts22h_Ext_Temp_PnPL.c Stts22h_Temp_PnPL.c Tags_Info_PnPL.c Tsc1641_Pow_PnPL.c Wifi_Config_PnPL.c Iis2dulpx_Acc_PnPL.c Iis2dulpx_Mlc_PnPL.c Iis2iclx_Mlc_PnPL.c Iis3dwb10is_Acc_PnPL.c Ilps28qsw_Press_PnPL.c Ism6hg256x_Gyro_PnPL.c Ism6hg256x_H_Acc_PnPL.c Ism6hg256x_L_Acc_PnPL.c Ism6hg256x_Mlc_PnPL.c Iis3dwb10is_Ispu_PnPL.c
  group Application/USBX
    ../USBX/App/: PCDDriver.c usbx_callbacks.c usbx_dctrl_class.c ux_device_descriptors.c
  group eLooM_Components/SensorManager
    ../../../../eLooM_Components/SensorManager/Src/drivers/: AnalogMicDriver.c I2CMasterDriver.c MDFDriver.c SPIMasterDriver.c
    ../../../../eLooM_Components/SensorManager/Src/services/: SIterator.c SQuery.c SUcfProtocol.c
    ../../../../eLooM_Components/SensorManager/Src/: ABusIF.c I3CBusIF.c I2CBusIF.c I2CBusTask.c IIS2DLPCTask.c IIS2ICLXTask.c IIS2MDCTask.c IIS3DWBTask.c ILPS22QSTask.c IMP23ABSUTask.c IMP34DT05Task.c ISM330DHCXTask.c SensorManager.c SensorRegister.c SMMessageParser.c SPIBusIF.c SPIBusTask.c STTS22HTask.c ISM330ISTask.c ISM330BXTask.c TSC1641Task.c IIS2DULPXTask.c IIS3DWB10ISTask.c ILPS28QSWTask.c ISM6HG256XTask.c
  group eLooM_Components/EMData
    ../../../../eLooM_Components/EMData/Src/events/: DataEventSrc.c
    ../../../../eLooM_Components/EMData/Src/services/: CircularBuffer.c em_data_format.c
  group eLooM_Components/TagManager
    ../../../../eLooM_Components/TagManager/Src/: TagManager.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/iis2dlpc/: iis2dlpc_reg.c
    ../../../../../Drivers/BSP/Components/iis2iclx/: iis2iclx_reg.c
    ../../../../../Drivers/BSP/Components/iis2mdc/: iis2mdc_reg.c
    ../../../../../Drivers/BSP/Components/iis3dwb/: iis3dwb_reg.c
    ../../../../../Drivers/BSP/Components/ilps22qs/: ilps22qs_reg.c
    ../../../../../Drivers/BSP/Components/ism330bx/: ism330bx_reg.c
    ../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx_reg.c
    ../../../../../Drivers/BSP/Components/ism330is/: ism330is_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c
    ../../../../../Drivers/BSP/Components/mx_wifi/core/: mx_address.c mx_wifi_hci.c mx_wifi_ipc.c
    ../../../../../Drivers/BSP/Components/mx_wifi/io_pattern/: mx_wifi_spi.c
    ../../../../../Drivers/BSP/Components/mx_wifi/: mx_wifi.c
    ../../../../../Drivers/BSP/Components/iis2dulpx/: iis2dulpx_reg.c
    ../../../../../Drivers/BSP/Components/iis3dwb10is/: iis3dwb10is_reg.c
    ../../../../../Drivers/BSP/Components/ilps28qsw/: ilps28qsw_reg.c
    ../../../../../Drivers/BSP/Components/ism6hg256x/: ism6hg256x_reg.c
  group Drivers/BSP/STWIN.box
    ../../../../../Drivers/BSP/STWIN.box/: STWIN.box_debug_pins.c STWIN.box.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dac.c stm32u5xx_hal_dac_ex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_dma2d.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_mdf.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c stm32u5xx_hal_lptim.c
  group Middlewares/Third_Party/parson
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/ST/BlueNRG-2
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_dev_config.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/ST/eLooM
    ../../../../../Middlewares/ST/eLooM/Src/events/: AEventSrc.c
    ../../../../../Middlewares/ST/eLooM/Src/services/: AManagedTask.c AManagedTaskEx.c ApplicationContext.c NullErrorDelegate.c sysdebug.c SysDefPowerModeHelper.c syserror.c sysinit.c SysTimestamp.c
    ../../../../../Middlewares/ST/eLooM/Src/drivers/: HwTSDriver.c SwTSDriver.c
  group Middlewares/ST/FileX
    ../../../../../Middlewares/ST/filex/common/src/: fx_directory_attributes_read.c fx_directory_attributes_set.c fx_directory_create.c fx_directory_default_get.c fx_directory_default_get_copy.c fx_directory_default_set.c fx_directory_delete.c fx_directory_entry_read.c fx_directory_entry_write.c fx_directory_exFAT_entry_read.c fx_directory_exFAT_entry_write.c fx_directory_exFAT_free_search.c fx_directory_exFAT_unicode_entry_write.c fx_directory_first_entry_find.c fx_directory_first_full_entry_find.c fx_directory_free_search.c fx_directory_information_get.c fx_directory_local_path_clear.c fx_directory_local_path_get.c fx_directory_local_path_get_copy.c fx_directory_local_path_restore.c fx_directory_local_path_set.c fx_directory_long_name_get.c fx_directory_long_name_get_extended.c fx_directory_name_extract.c fx_directory_name_test.c fx_directory_next_entry_find.c fx_directory_next_full_entry_find.c fx_directory_rename.c fx_directory_search.c fx_directory_short_name_get.c fx_directory_short_name_get_extended.c fx_file_allocate.c fx_file_attributes_read.c fx_file_attributes_set.c fx_file_best_effort_allocate.c fx_file_close.c fx_file_create.c fx_file_date_time_set.c fx_file_delete.c fx_file_extended_allocate.c fx_file_extended_best_effort_allocate.c fx_file_extended_relative_seek.c fx_file_extended_seek.c fx_file_extended_truncate.c fx_file_extended_truncate_release.c fx_file_open.c fx_file_read.c fx_file_relative_seek.c fx_file_rename.c fx_file_seek.c fx_file_truncate.c fx_file_truncate_release.c fx_file_write.c fx_file_write_notify_set.c fx_media_abort.c fx_media_boot_info_extract.c fx_media_cache_invalidate.c fx_media_check.c fx_media_check_FAT_chain_check.c fx_media_check_lost_cluster_check.c fx_media_close.c fx_media_close_notify_set.c fx_media_exFAT_format.c fx_media_extended_space_available.c fx_media_flush.c fx_media_format.c fx_media_format_oem_name_set.c fx_media_format_type_set.c fx_media_format_volume_id_set.c fx_media_open.c fx_media_open_notify_set.c fx_media_read.c fx_media_space_available.c fx_media_volume_get.c fx_media_volume_get_extended.c fx_media_volume_set.c fx_media_write.c fx_partition_offset_calculate.c fx_ram_driver.c fx_system_date_get.c fx_system_date_set.c fx_system_initialize.c fx_system_time_get.c fx_system_time_set.c fx_system_timer_entry.c fx_utility_16_unsigned_read.c fx_utility_16_unsigned_write.c fx_utility_32_unsigned_read.c fx_utility_32_unsigned_write.c fx_utility_64_unsigned_read.c fx_utility_64_unsigned_write.c fx_utility_absolute_path_get.c fx_utility_exFAT_allocate_new_cluster.c fx_utility_exFAT_bitmap_cache_prepare.c fx_utility_exFAT_bitmap_cache_update.c fx_utility_exFAT_bitmap_flush.c fx_utility_exFAT_bitmap_free_cluster_find.c fx_utility_exFAT_bitmap_initialize.c fx_utility_exFAT_bitmap_start_sector_get.c fx_utility_exFAT_cluster_free.c fx_utility_exFAT_cluster_state_get.c fx_utility_exFAT_cluster_state_set.c fx_utility_exFAT_geometry_check.c fx_utility_exFAT_name_hash_get.c fx_utility_exFAT_size_calculate.c fx_utility_exFAT_system_area_checksum_verify.c fx_utility_exFAT_system_area_checksum_write.c fx_utility_exFAT_system_area_format.c fx_utility_exFAT_system_sector_write.c fx_utility_exFAT_unicode_name_hash_get.c fx_utility_exFAT_upcase_table.c fx_utility_FAT_entry_read.c fx_utility_FAT_entry_write.c fx_utility_FAT_flush.c fx_utility_FAT_map_flush.c fx_utility_FAT_sector_get.c fx_utility_logical_sector_cache_entry_read.c fx_utility_logical_sector_flush.c fx_utility_logical_sector_read.c fx_utility_logical_sector_write.c fx_utility_memory_copy.c fx_utility_memory_set.c fx_utility_string_length_get.c fx_utility_token_length_get.c fxe_directory_attributes_read.c fxe_directory_attributes_set.c fxe_directory_create.c fxe_directory_default_get.c fxe_directory_default_get_copy.c fxe_directory_default_set.c fxe_directory_delete.c fxe_directory_first_entry_find.c fxe_directory_first_full_entry_find.c fxe_directory_information_get.c fxe_directory_local_path_clear.c fxe_directory_local_path_get.c fxe_directory_local_path_get_copy.c fxe_directory_local_path_restore.c fxe_directory_local_path_set.c fxe_directory_long_name_get.c fxe_directory_long_name_get_extended.c fxe_directory_name_test.c fxe_directory_next_entry_find.c fxe_directory_next_full_entry_find.c fxe_directory_rename.c fxe_directory_short_name_get.c fxe_directory_short_name_get_extended.c fxe_file_allocate.c fxe_file_attributes_read.c fxe_file_attributes_set.c fxe_file_best_effort_allocate.c fxe_file_close.c fxe_file_create.c fxe_file_date_time_set.c fxe_file_delete.c fxe_file_extended_allocate.c fxe_file_extended_best_effort_allocate.c fxe_file_extended_relative_seek.c fxe_file_extended_seek.c fxe_file_extended_truncate.c fxe_file_extended_truncate_release.c fxe_file_open.c fxe_file_read.c fxe_file_relative_seek.c fxe_file_rename.c fxe_file_seek.c fxe_file_truncate.c fxe_file_truncate_release.c fxe_file_write.c fxe_file_write_notify_set.c fxe_media_abort.c fxe_media_cache_invalidate.c fxe_media_check.c fxe_media_close.c fxe_media_close_notify_set.c fxe_media_exFAT_format.c fxe_media_extended_space_available.c fxe_media_flush.c fxe_media_format.c fxe_media_open.c fxe_media_open_notify_set.c fxe_media_read.c fxe_media_space_available.c fxe_media_volume_get.c fxe_media_volume_get_extended.c fxe_media_volume_set.c fxe_media_write.c fxe_system_date_get.c fxe_system_date_set.c fxe_system_time_get.c fxe_system_time_set.c
    ../../../../../Middlewares/ST/filex/common/drivers/: fx_stm32_sd_driver.c
  group Middlewares/ST/PnPLCompManager
    ../../../../../Middlewares/ST/PnPLCompManager/Src/: IPnPLComponent.c PnPLCompManager.c
  group Middlewares/ST/STM32_BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: ble_machine_learning_core.c ble_manager.c ble_pn_p_like.c ble_high_speed_data_log.c ble_raw_pn_pl_controlled.c
  group Middlewares/ST/ThreadX
    ../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_secure_stack_allocate.S tx_thread_secure_stack_free.S tx_thread_secure_stack_initialize.S
  group Middlewares/ST/usbx/core
    ../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_class_dpump_activate.c ux_device_class_dpump_change.c ux_device_class_dpump_deactivate.c ux_device_class_dpump_entry.c ux_device_class_dpump_initialize.c ux_device_class_dpump_read.c ux_device_class_dpump_thread.c ux_device_class_dpump_write.c ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_free_block_best_get.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c
  group Middlewares/ST/usbx/controller
    ../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c
  group Middlewares/ST/SensorStreaming_USBX
    ../../../../../Middlewares/ST/SensorStreaming_USBX/: ux_device_class_sensor_streaming_activate.c ux_device_class_sensor_streaming_api.c ux_device_class_sensor_streaming_bulkin_thread.c ux_device_class_sensor_streaming_control_request.c ux_device_class_sensor_streaming_deactivate.c ux_device_class_sensor_streaming_entry.c ux_device_class_sensor_streaming_initialize.c ux_device_class_sensor_streaming_read.c ux_device_class_sensor_streaming_sof.c ux_device_class_sensor_streaming_thread.c ux_device_class_sensor_streaming_write.c
  group Middlewares\ST\CircularBufferDL2
    ../../../../../Middlewares/ST/CircularBufferDL2/: CircularBufferDL2.c
  group Middlewares/ST/netxduo
    ../../../../../Middlewares/ST/netxduo/addons/dhcp/: nxd_dhcp_client.c
    ../../../../../Middlewares/ST/netxduo/addons/dns/: nxd_dns.c
    ../../../../../Middlewares/ST/netxduo/addons/sntp/: nxd_sntp_client.c
    ../../../../../Middlewares/ST/netxduo/common/drivers/wifi/mxchip/: nx_driver_emw3080.c
    ../../../../../Middlewares/ST/netxduo/common/src/: nx_arp_announce_send.c nx_arp_dynamic_entries_invalidate.c nx_arp_dynamic_entry_delete.c nx_arp_dynamic_entry_set.c nx_arp_enable.c nx_arp_entry_allocate.c nx_arp_entry_delete.c nx_arp_gratuitous_send.c nx_arp_hardware_address_find.c nx_arp_info_get.c nx_arp_initialize.c nx_arp_interface_entries_delete.c nx_arp_ip_address_find.c nx_arp_packet_deferred_receive.c nx_arp_packet_receive.c nx_arp_packet_send.c nx_arp_periodic_update.c nx_arp_probe_send.c nx_arp_queue_process.c nx_arp_queue_send.c nx_arp_static_entries_delete.c nx_arp_static_entry_create.c nx_arp_static_entry_delete.c nx_arp_static_entry_delete_internal.c nx_icmp_cleanup.c nx_icmp_enable.c nx_icmp_info_get.c nx_icmp_interface_ping.c nx_icmp_interface_ping6.c nx_icmp_packet_process.c nx_icmp_packet_receive.c nx_icmp_ping.c nx_icmp_ping6.c nx_icmp_queue_process.c nx_icmpv4_packet_process.c nx_icmpv4_process_echo_reply.c nx_icmpv4_process_echo_request.c nx_icmpv4_send_error_message.c nx_igmp_multicast_check.c nx_invalidate_destination_entry.c nx_ip_address_change_notify.c nx_ip_address_get.c nx_ip_address_set.c nx_ip_auxiliary_packet_pool_set.c nx_ip_checksum_compute.c nx_ip_create.c nx_ip_deferred_link_status_process.c nx_ip_delete.c nx_ip_delete_queue_clear.c nx_ip_dispatch_process.c nx_ip_driver_deferred_enable.c nx_ip_driver_deferred_processing.c nx_ip_driver_deferred_receive.c nx_ip_driver_direct_command.c nx_ip_driver_interface_direct_command.c nx_ip_driver_link_status_event.c nx_ip_driver_packet_send.c nx_ip_fast_periodic_timer_entry.c nx_ip_forward_packet_process.c nx_ip_forwarding_disable.c nx_ip_forwarding_enable.c nx_ip_fragment_assembly.c nx_ip_fragment_disable.c nx_ip_fragment_enable.c nx_ip_fragment_forward_packet.c nx_ip_fragment_packet.c nx_ip_fragment_timeout_check.c nx_ip_gateway_address_clear.c nx_ip_gateway_address_get.c nx_ip_gateway_address_set.c nx_ip_header_add.c nx_ip_info_get.c nx_ip_initialize.c nx_ip_interface_address_get.c nx_ip_interface_address_mapping_configure.c nx_ip_interface_address_set.c nx_ip_interface_attach.c nx_ip_interface_capability_get.c nx_ip_interface_capability_set.c nx_ip_interface_detach.c nx_ip_interface_info_get.c nx_ip_interface_mtu_set.c nx_ip_interface_physical_address_get.c nx_ip_interface_physical_address_set.c nx_ip_interface_status_check.c nx_ip_link_status_change_notify_set.c nx_ip_max_payload_size_find.c nx_ip_packet_checksum_compute.c nx_ip_packet_deferred_receive.c nx_ip_packet_receive.c nx_ip_packet_send.c nx_ip_periodic_timer_entry.c nx_ip_raw_packet_cleanup.c nx_ip_raw_packet_disable.c nx_ip_raw_packet_enable.c nx_ip_raw_packet_filter_set.c nx_ip_raw_packet_processing.c nx_ip_raw_packet_receive.c nx_ip_raw_packet_send.c nx_ip_raw_packet_source_send.c nx_ip_raw_receive_queue_max_set.c nx_ip_route_find.c nx_ip_static_route_add.c nx_ip_static_route_delete.c nx_ip_status_check.c nx_ip_thread_entry.c nx_ipv4_multicast_interface_join.c nx_ipv4_multicast_interface_leave.c nx_ipv4_option_process.c nx_ipv4_packet_receive.c nx_packet_allocate.c nx_packet_copy.c nx_packet_data_adjust.c nx_packet_data_append.c nx_packet_data_extract_offset.c nx_packet_data_retrieve.c nx_packet_debug_info_get.c nx_packet_length_get.c nx_packet_pool_cleanup.c nx_packet_pool_create.c nx_packet_pool_delete.c nx_packet_pool_info_get.c nx_packet_pool_initialize.c nx_packet_pool_low_watermark_set.c nx_packet_release.c nx_packet_transmit_release.c nx_rarp_packet_deferred_receive.c nx_system_initialize.c nx_tcp_cleanup_deferred.c nx_tcp_client_bind_cleanup.c nx_tcp_client_socket_bind.c nx_tcp_client_socket_connect.c nx_tcp_client_socket_port_get.c nx_tcp_client_socket_unbind.c nx_tcp_connect_cleanup.c nx_tcp_deferred_cleanup_check.c nx_tcp_disconnect_cleanup.c nx_tcp_enable.c nx_tcp_fast_periodic_processing.c nx_tcp_free_port_find.c nx_tcp_info_get.c nx_tcp_initialize.c nx_tcp_mss_option_get.c nx_tcp_no_connection_reset.c nx_tcp_packet_process.c nx_tcp_packet_receive.c nx_tcp_packet_send_ack.c nx_tcp_packet_send_control.c nx_tcp_packet_send_fin.c nx_tcp_packet_send_probe.c nx_tcp_packet_send_rst.c nx_tcp_packet_send_syn.c nx_tcp_periodic_processing.c nx_tcp_queue_process.c nx_tcp_receive_cleanup.c nx_tcp_server_socket_accept.c nx_tcp_server_socket_driver_listen.c nx_tcp_server_socket_listen.c nx_tcp_server_socket_relisten.c nx_tcp_server_socket_unaccept.c nx_tcp_server_socket_unlisten.c nx_tcp_socket_block_cleanup.c nx_tcp_socket_bytes_available.c nx_tcp_socket_connection_reset.c nx_tcp_socket_create.c nx_tcp_socket_delete.c nx_tcp_socket_disconnect.c nx_tcp_socket_disconnect_complete_notify.c nx_tcp_socket_driver_establish.c nx_tcp_socket_driver_packet_receive.c nx_tcp_socket_establish_notify.c nx_tcp_socket_info_get.c nx_tcp_socket_mss_get.c nx_tcp_socket_mss_peer_get.c nx_tcp_socket_mss_set.c nx_tcp_socket_packet_process.c nx_tcp_socket_peer_info_get.c nx_tcp_socket_queue_depth_notify_set.c nx_tcp_socket_receive.c nx_tcp_socket_receive_notify.c nx_tcp_socket_receive_queue_flush.c nx_tcp_socket_receive_queue_max_set.c nx_tcp_socket_retransmit.c nx_tcp_socket_send.c nx_tcp_socket_send_internal.c nx_tcp_socket_state_ack_check.c nx_tcp_socket_state_closing.c nx_tcp_socket_state_data_check.c nx_tcp_socket_state_established.c nx_tcp_socket_state_fin_wait1.c nx_tcp_socket_state_fin_wait2.c nx_tcp_socket_state_last_ack.c nx_tcp_socket_state_syn_received.c nx_tcp_socket_state_syn_sent.c nx_tcp_socket_state_transmit_check.c nx_tcp_socket_state_wait.c nx_tcp_socket_thread_resume.c nx_tcp_socket_thread_suspend.c nx_tcp_socket_timed_wait_callback.c nx_tcp_socket_transmit_configure.c nx_tcp_socket_transmit_queue_flush.c nx_tcp_socket_window_update_notify_set.c nx_tcp_transmit_cleanup.c nx_tcp_window_scaling_option_get.c nx_udp_bind_cleanup.c nx_udp_enable.c nx_udp_free_port_find.c nx_udp_info_get.c nx_udp_packet_info_extract.c nx_udp_packet_receive.c nx_udp_receive_cleanup.c nx_udp_socket_bind.c nx_udp_socket_bytes_available.c nx_udp_socket_checksum_disable.c nx_udp_socket_checksum_enable.c nx_udp_socket_create.c nx_udp_socket_delete.c nx_udp_socket_driver_packet_receive.c nx_udp_socket_info_get.c nx_udp_socket_port_get.c nx_udp_socket_receive.c nx_udp_socket_receive_notify.c nx_udp_socket_send.c nx_udp_socket_source_send.c nx_udp_socket_unbind.c nx_udp_source_extract.c nx_utility.c nxd_icmp_enable.c nxd_icmp_ping.c nxd_icmp_source_ping.c nxd_ip_raw_packet_send.c nxd_ip_raw_packet_source_send.c nxd_tcp_client_socket_connect.c nxd_tcp_socket_peer_info_get.c nxd_udp_packet_info_extract.c nxd_udp_socket_send.c nxd_udp_socket_source_send.c nxd_udp_source_extract.c nxde_icmp_enable.c nxde_icmp_ping.c nxde_icmp_source_ping.c nxde_ip_raw_packet_send.c nxde_ip_raw_packet_source_send.c nxde_tcp_client_socket_connect.c nxde_tcp_socket_peer_info_get.c nxde_udp_packet_info_extract.c nxde_udp_socket_send.c nxde_udp_socket_source_send.c nxde_udp_source_extract.c nxe_arp_dynamic_entries_invalidate.c nxe_arp_dynamic_entry_set.c nxe_arp_enable.c nxe_arp_entry_delete.c nxe_arp_gratuitous_send.c nxe_arp_hardware_address_find.c nxe_arp_info_get.c nxe_arp_ip_address_find.c nxe_arp_static_entries_delete.c nxe_arp_static_entry_create.c nxe_arp_static_entry_delete.c nxe_icmp_enable.c nxe_icmp_info_get.c nxe_icmp_ping.c nxe_ip_address_change_notify.c nxe_ip_address_get.c nxe_ip_address_set.c nxe_ip_auxiliary_packet_pool_set.c nxe_ip_create.c nxe_ip_delete.c nxe_ip_driver_direct_command.c nxe_ip_driver_interface_direct_command.c nxe_ip_forwarding_disable.c nxe_ip_forwarding_enable.c nxe_ip_fragment_disable.c nxe_ip_fragment_enable.c nxe_ip_gateway_address_clear.c nxe_ip_gateway_address_get.c nxe_ip_gateway_address_set.c nxe_ip_info_get.c nxe_ip_interface_address_get.c nxe_ip_interface_address_mapping_configure.c nxe_ip_interface_address_set.c nxe_ip_interface_attach.c nxe_ip_interface_capability_get.c nxe_ip_interface_capability_set.c nxe_ip_interface_detach.c nxe_ip_interface_info_get.c nxe_ip_interface_mtu_set.c nxe_ip_interface_physical_address_get.c nxe_ip_interface_physical_address_set.c nxe_ip_interface_status_check.c nxe_ip_link_status_change_notify_set.c nxe_ip_max_payload_size_find.c nxe_ip_raw_packet_disable.c nxe_ip_raw_packet_enable.c nxe_ip_raw_packet_filter_set.c nxe_ip_raw_packet_receive.c nxe_ip_raw_packet_send.c nxe_ip_raw_packet_source_send.c nxe_ip_raw_receive_queue_max_set.c nxe_ip_static_route_add.c nxe_ip_static_route_delete.c nxe_ip_status_check.c nxe_ipv4_multicast_interface_join.c nxe_ipv4_multicast_interface_leave.c nxe_packet_allocate.c nxe_packet_copy.c nxe_packet_data_append.c nxe_packet_data_extract_offset.c nxe_packet_data_retrieve.c nxe_packet_length_get.c nxe_packet_pool_create.c nxe_packet_pool_delete.c nxe_packet_pool_info_get.c nxe_packet_pool_low_watermark_set.c nxe_packet_release.c nxe_packet_transmit_release.c nxe_tcp_client_socket_bind.c nxe_tcp_client_socket_connect.c nxe_tcp_client_socket_port_get.c nxe_tcp_client_socket_unbind.c nxe_tcp_enable.c nxe_tcp_free_port_find.c nxe_tcp_info_get.c nxe_tcp_server_socket_accept.c nxe_tcp_server_socket_listen.c nxe_tcp_server_socket_relisten.c nxe_tcp_server_socket_unaccept.c nxe_tcp_server_socket_unlisten.c nxe_tcp_socket_bytes_available.c nxe_tcp_socket_create.c nxe_tcp_socket_delete.c nxe_tcp_socket_disconnect.c nxe_tcp_socket_disconnect_complete_notify.c nxe_tcp_socket_establish_notify.c nxe_tcp_socket_info_get.c nxe_tcp_socket_mss_get.c nxe_tcp_socket_mss_peer_get.c nxe_tcp_socket_mss_set.c nxe_tcp_socket_peer_info_get.c nxe_tcp_socket_queue_depth_notify_set.c nxe_tcp_socket_receive.c nxe_tcp_socket_receive_notify.c nxe_tcp_socket_receive_queue_max_set.c nxe_tcp_socket_send.c nxe_tcp_socket_state_wait.c nxe_tcp_socket_timed_wait_callback.c nxe_tcp_socket_transmit_configure.c nxe_tcp_socket_window_update_notify_set.c nxe_udp_enable.c nxe_udp_free_port_find.c nxe_udp_info_get.c nxe_udp_packet_info_extract.c nxe_udp_socket_bind.c nxe_udp_socket_bytes_available.c nxe_udp_socket_checksum_disable.c nxe_udp_socket_checksum_enable.c nxe_udp_socket_create.c nxe_udp_socket_delete.c nxe_udp_socket_info_get.c nxe_udp_socket_port_get.c nxe_udp_socket_receive.c nxe_udp_socket_receive_notify.c nxe_udp_socket_send.c nxe_udp_socket_source_send.c nxe_udp_socket_unbind.c nxe_udp_source_extract.c nxe_igmp_multicast_interface_join.c nxe_igmp_multicast_interface_leave.c nxe_igmp_enable.c nxe_igmp_info_get.c nxe_igmp_loopback_disable.c nxe_igmp_loopback_enable.c nxe_igmp_multicast_join.c nxe_igmp_multicast_leave.c nx_igmp_enable.c nx_igmp_info_get.c nx_igmp_interface_report_send.c nx_igmp_loopback_disable.c nx_igmp_loopback_enable.c nx_igmp_multicast_interface_join.c nx_igmp_multicast_interface_join_internal.c nx_igmp_multicast_interface_leave.c nx_igmp_multicast_interface_leave_internal.c nx_igmp_multicast_join.c nx_igmp_multicast_leave.c nx_igmp_packet_process.c nx_igmp_packet_receive.c nx_igmp_periodic_processing.c nx_igmp_queue_process.c
target Datalog2_Release (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: as above
  output: Datalog2_Release +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: SYS_TP_MCU_STM32U5, USE_FULL_ASSERT, SYS_TRACE=0, SYS_DBG_ENABLE_TA4=0, NX_INCLUDE_USER_DEFINE_FILE, TX_INCLUDE_USER_DEFINE_FILE, UX_INCLUDE_USER_DEFINE_FILE, USE_HAL_DRIVER, STM32U585xx
  c misc: --include=sysconfig.h
  c include: as above
  asm define: USE_DYNAMIC_MEMORY_ALLOCATION, TX_SINGLE_MODE_NON_SECURE=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0
